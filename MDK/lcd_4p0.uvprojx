# Keil uVision project lcd_4p0.uvprojx, settings and files
target lcd_4p0_Debug (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.9
  cpu: IROM1(0x00000000,0x200000) IROM2(0x03000000,0x1800) IRAM1(0x1FFE0000,0x80000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: lcd_4p0 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __DEBUG,HC32F4A0,USE_DDL_DRIVER,
  c include: ..\source;..\drivers\cmsis\Device\HDSC\hc32f4xx\Include;..\drivers\cmsis\Include;..\drivers\hc32_ll_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\config\linker\HC32F4A0xI.sct
  link misc: --keep=*Handler
  group cmsis
    ./: startup_hc32f4a0.s
    ../drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f4a0.c
  group source
    ../source/: main.c bsp_board.c bsp_lcd.c lcd_panel.c bsp_touch_ft6336.c
  group driver
    ../drivers/hc32_ll_driver/src/: hc32_ll.c hc32_ll_clk.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_gpio.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_pwc.c hc32_ll_smc.c hc32_ll_sram.c hc32_ll_usart.c hc32_ll_utility.c
  group headers
    ../source/: main.h hc32f4xx_conf.h lcd_config.h bsp_board.h bsp_lcd.h lcd_panel.h bsp_touch_ft6336.h
  group doc
    ../: README.txt
target lcd_4p0_Release (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.9
  cpu: as above
  output: lcd_4p0 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HC32F4A0,USE_DDL_DRIVER,
  c include: ..\source;..\drivers\cmsis\Device\HDSC\hc32f4xx\Include;..\drivers\cmsis\Include;..\drivers\hc32_ll_driver\inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\config\linker\HC32F4A0xI.sct
  link misc: --keep=*Handler
